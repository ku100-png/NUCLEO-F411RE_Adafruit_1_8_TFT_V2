# Keil uVision project Project.uvprojx, settings and files
target STM32F4xx_Nucleo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2001FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,USE_STM32F4XX_NUCLEO
  c misc: --C99
  c include: ../Core/Inc;../Drivers/BSP/STM32F4xx-Nucleo;../Drivers/BSP/Adafruit_Shield;../Middlewares/FatFs;../Drivers/STM32F4xx_HAL_Driver/Inc;../FatFs
  asm include: ../Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Middlewares/FatFs/Core
    ../Middlewares/FatFs/: diskio.c ff.c ff_gen_drv.c syscall.c unicode.c
  group Drivers/BSP/Adafruit_Shield
    ../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_lcd.c stm32_adafruit_sd.c
  group Application/Core/Src
    ../Core/Src/: fatfs_storage.c main.c sd_diskio.c stm32f4xx_it.c system_stm32f4xx.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/st7735/: st7735.c
    ../Drivers/BSP/Components/adafruit_seesaw/: adafruit_seesaw.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
